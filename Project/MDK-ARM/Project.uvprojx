# Keil uVision project Project.uvprojx, settings and files
target Unify (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER,HSE_VALUE=12000000
  c include: ..\..\Project;..\..\Libraries\CMSIS\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\APP;..\..\BSP;..\..\Comtest;..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group User
    ../: main.c FreeRTOSConfig.h stm32f2xx_it.c
  group App
    ../../App/: app.c
  group Bsp
    ../../Bsp/: Base_Fun.c bsp.c oled.c Com2Server.c rtc.c Rsing_I2C.c finger.c display_task.c flash.c flash_task.c Rsing_Beep.c default_task.c
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_pwr.c misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_tim.c stm32f2xx_usart.c
  group FreeRTOS
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../../FreeRTOS/portable/MemMang/: heap_2.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group CMSIS
    ../: system_stm32f2xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
